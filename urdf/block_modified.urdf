Commit message: some changes applied

File: urdf/block_modified.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link block_2_base_link: geometry collision box size=0.05 0.05 0.04; visual box size=0.05 0.05 0.04
